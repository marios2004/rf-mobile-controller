options:
  parameters:
    author: RF Mobile Controller
    description: HackRF Spectrum Analyzer for sub-GHz signals
    generate_options: qt_gui
    id: hackrf_spectrum
    output_language: python
    title: HackRF Spectrum Analyzer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Freq (MHz)
    start: '300'
    step: '0.01'
    stop: '928'
    value: '315.07'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: LNA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: VGA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
  states: {}
- name: freq_hz
  id: variable
  parameters:
    value: int(center_freq * 1e6)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq_hz
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: vga_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq_hz
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,0,1,4
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_hz
    fftsize: fft_size
    gui_hint: 2,0,1,4
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,0,1,4
    label1: Magnitude
    name: '"Signal Amplitude"'
    size: '2048'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymin: '0'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
