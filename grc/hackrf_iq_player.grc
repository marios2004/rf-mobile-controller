options:
  parameters:
    author: RF Mobile Controller
    description: Play back IQ files through HackRF (transmit)
    generate_options: qt_gui
    id: hackrf_iq_player
    output_language: python
    title: HackRF IQ File Player
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: TX Freq (MHz)
    start: '300'
    step: '0.01'
    stop: '928'
    value: '315.07'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: TX Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: '40'
  states: {}
- name: iq_file
  id: parameter
  parameters:
    label: IQ File Path
    short_id: f
    type: str
    value: '"/tmp/signal.iq"'
  states: {}
- name: repeat_tx
  id: variable_qtgui_check_box
  parameters:
    gui_hint: 0,3,1,1
    label: Repeat
    true_value: 'True'
    false_value: 'False'
    value: 'False'
  states: {}
- name: freq_hz
  id: variable
  parameters:
    value: int(center_freq * 1e6)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: iq_file
    repeat: repeat_tx
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127.0'
    vector_input: 'False'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq_hz
    gain0: tx_gain
    if_gain0: '40'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,4
    label1: TX Signal
    name: '"Transmitting"'
    size: '4096'
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', osmosdr_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
