options:
  parameters:
    author: RF Mobile Controller
    description: OOK Demodulator for car key fob signals
    generate_options: qt_gui
    id: hackrf_ook_demod
    output_language: python
    title: OOK Demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Freq (MHz)
    start: '300'
    step: '0.01'
    stop: '928'
    value: '315.07'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: LNA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: VGA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: OOK Threshold
    min_len: '100'
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: freq_hz
  id: variable
  parameters:
    value: int(center_freq * 1e6)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq_hz
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: vga_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold * 0.8
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,5
    label1: Raw Magnitude
    label2: Digital Output
    name: '"OOK Signal"'
    nconnections: '2'
    size: '20000'
    srate: samp_rate / decimation
    tr_chan: '1'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    width2: '2'
    ymax: '1.5'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_hz
    fftsize: '1024'
    gui_hint: 2,0,1,5
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
