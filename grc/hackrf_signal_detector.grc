options:
  parameters:
    author: RF Mobile Controller
    description: Signal detector with ZMQ output for backend integration
    generate_options: qt_gui
    id: hackrf_signal_detector
    output_language: python
    title: HackRF Signal Detector
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Center Freq (MHz)
    start: '300'
    step: '0.01'
    stop: '928'
    value: '315.07'
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: LNA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: VGA Gain
    min_len: '100'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
  states: {}
- name: min_snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Min SNR (dB)
    min_len: '100'
    start: '5'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: freq_hz
  id: variable
  parameters:
    value: int(center_freq * 1e6)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: '20'
    freq0: freq_hz
    gain0: lna_gain
    gain_mode0: 'False'
    if_gain0: vga_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq_hz
    fftsize: fft_size
    grid: 'True'
    gui_hint: 1,0,1,5
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_hz
    fftsize: fft_size
    gui_hint: 2,0,1,5
    int_max: '0'
    int_min: '-100'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'True'
    avg_alpha: '0.3'
    fft_size: fft_size
    frame_rate: '15'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: epy_block_peak_detector
  id: epy_block
  parameters:
    _source_code: |
      """Peak Detector - detects signals and publishes via ZMQ"""
      import numpy as np
      from gnuradio import gr
      import zmq
      import json
      import time


      class blk(gr.sync_block):
          """Detects peaks in FFT data and publishes via ZMQ"""

          def __init__(self, fft_size=1024, samp_rate=2000000.0, center_freq=315070000.0,
                       min_snr_db=10.0, zmq_port=5555):
              gr.sync_block.__init__(
                  self,
                  name='Peak Detector',
                  in_sig=[(np.float32, fft_size)],
                  out_sig=None
              )
              self._fft_size = fft_size
              self._samp_rate = samp_rate
              self.center_freq = center_freq
              self._min_snr_db = min_snr_db
              self._ctx = zmq.Context()
              self._pub = self._ctx.socket(zmq.PUB)
              try:
                  self._pub.bind("tcp://127.0.0.1:{}".format(int(zmq_port)))
              except zmq.error.ZMQError:
                  self._pub = None
              self._last = 0

          def work(self, input_items, output_items):
              now = time.time()
              if now - self._last < 0.2:
                  return len(input_items[0])
              
              for fft_db in input_items[0]:
                  noise = float(np.median(fft_db))
                  thresh = noise + self._min_snr_db
                  above = fft_db > thresh
                  
                  if not np.any(above):
                      continue
                  
                  peaks = []
                  in_pk = False
                  start = 0
                  
                  for i in range(len(fft_db)):
                      if above[i] and not in_pk:
                          in_pk = True
                          start = i
                      elif not above[i] and in_pk:
                          in_pk = False
                          region = fft_db[start:i]
                          mx = start + int(np.argmax(region))
                          fo = (mx - self._fft_size / 2.0) * (self._samp_rate / self._fft_size)
                          pf = self.center_freq + fo
                          peaks.append({
                              "freq_hz": round(float(pf), 1),
                              "freq_mhz": round(float(pf / 1e6), 4),
                              "power_db": round(float(fft_db[mx]), 1),
                              "noise_db": round(noise, 1),
                              "snr_db": round(float(fft_db[mx]) - noise, 1),
                              "timestamp": now,
                          })
                  
                  if in_pk:
                      region = fft_db[start:]
                      mx = start + int(np.argmax(region))
                      fo = (mx - self._fft_size / 2.0) * (self._samp_rate / self._fft_size)
                      pf = self.center_freq + fo
                      peaks.append({
                          "freq_hz": round(float(pf), 1),
                          "freq_mhz": round(float(pf / 1e6), 4),
                          "power_db": round(float(fft_db[mx]), 1),
                          "noise_db": round(noise, 1),
                          "snr_db": round(float(fft_db[mx]) - noise, 1),
                          "timestamp": now,
                      })
                  
                  if peaks:
                      peaks.sort(key=lambda p: p["power_db"], reverse=True)
                      if self._pub:
                          for p in peaks[:3]:
                              self._pub.send_string(json.dumps(p))
                      self._last = now
              
              return len(input_items[0])
    center_freq: freq_hz
    fft_size: fft_size
    min_snr_db: min_snr
    samp_rate: samp_rate
    zmq_port: '5555'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', logpwrfft_x_0, '0']
- [logpwrfft_x_0, '0', epy_block_peak_detector, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
